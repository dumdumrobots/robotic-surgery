Commit message: Update files.

File: instrument_description/urdf/instrument.urdf (robot description, URDF)
Before this commit: robot robotic_instrument, 7 links, 6 joints
Joints:
- joint frame__platform: origin xyz=0 0 0.14 rpy=0 0 0 -> xyz=0 0 0.48 rpy=0 0 0
